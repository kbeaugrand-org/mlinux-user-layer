DESCRIPTION = "LoRa Packet Forwarder bitbake append"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"